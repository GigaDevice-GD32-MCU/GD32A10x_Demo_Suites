# Keil uVision project usbh_hid.uvprojx, settings and files
target usbh_hid (6120000::V6.12::.\ARMCLANG)
  device: GD32A103VB GigaDevice
  pack: GigaDevice.GD32A10x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usbh_hid +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32A10X  GD32A103V_EVAL
  c include: ..\inc;..\..\..\..\..\..\GD32A10x_Firmware_Library\CMSIS\GD\GD32A10x\Include;..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_standard_peripheral\Include;..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\driver\Include;..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\host\core\Include;..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\host\class\hid\Include;..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\ustd\common;..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\ustd\class\hid;..\..\..\..\..\Utilities\LCD_Commom;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: gd32a10x_it.c gd32a10x_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../../../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group GD32A10x_Peripherals
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_standard_peripheral/Source/: gd32a10x_exmc.c gd32a10x_exti.c gd32a10x_fmc.c gd32a10x_gpio.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_timer.c gd32a10x_usart.c
  group GD32A10x_EVAL
    ../src/: lcd_font.c lcd_log.c gd32a103v_lcd_eval.c
    ../../../../../Utilities/: gd32a103v_eval.c
  group USB_Driver
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group Startup
    ../../../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/ARM/: startup_gd32a10x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
