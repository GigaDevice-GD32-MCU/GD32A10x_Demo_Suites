# IAR project usbh_msc.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32A103xB GD GD32A103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32A10X; GD32A103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\..\GD32A10x_Firmware_Library\CMSIS\GD\GD32A10x\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_standard_peripheral\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\host\class\msc\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\host\core\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\ustd\class\msc; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.srec
  ILINK.IlinkOutputFile: usbh_msc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32a10x_it.c gd32a10x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../../../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group Doc
    ../: readme.txt
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group GD32A10x_EVAL
    ../../../../../Utilities/: gd32a103v_eval.c
    ../src/: gd32a103v_lcd_eval.c lcd_font.c lcd_log.c
  group GD32A10x_Peripherals
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_standard_peripheral/Source/: gd32a10x_dma.c gd32a10x_exmc.c gd32a10x_exti.c gd32a10x_gpio.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_timer.c gd32a10x_usart.c
  group Startup
    ../../../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/IAR/: startup_gd32a10x.s
  group USB_Class
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Drivers
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
