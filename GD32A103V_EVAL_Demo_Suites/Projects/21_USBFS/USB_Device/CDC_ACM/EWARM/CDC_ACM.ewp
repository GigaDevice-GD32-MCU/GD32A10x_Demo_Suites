# IAR project CDC_ACM.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32A103xB GD GD32A103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32A10X; GD32A103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\..\GD32A10x_Firmware_Library\CMSIS\GD\GD32A10x\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_standard_peripheral\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\device\class\cdc\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\device\core\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\driver\Include; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\ustd\class\cdc; ..\..\..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: cdc_acm.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32A103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c gd32a10x_hw.c gd32a10x_it.c
  group CMSIS
    ../../../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group Doc
    ../: readme.txt
  group GD32A10x_EVAL
    ../../../../../Utilities/: gd32a103v_eval.c
  group GD32A10x_StdPeriph
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_standard_peripheral/Source/: gd32a10x_ctc.c gd32a10x_dma.c gd32a10x_exti.c gd32a10x_fmc.c gd32a10x_gpio.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_timer.c gd32a10x_usart.c
  group Startup
    ../../../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/IAR/: startup_gd32a10x.s
  group USB_Class
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group USB_Device
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../../GD32A10x_Firmware_Library/GD32A10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
