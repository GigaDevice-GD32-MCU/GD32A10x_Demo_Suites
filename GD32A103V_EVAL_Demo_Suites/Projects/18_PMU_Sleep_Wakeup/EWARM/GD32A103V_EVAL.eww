<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GD32A103V_EVAL.ewp</path>
    </project>
    <batchBuild />
</workspace>
