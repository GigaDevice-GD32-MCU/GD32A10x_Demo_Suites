# Keil uVision project GD32A103V_EVAL.uvprojx, settings and files
target GD32A103V_EVAL (6130001::V6.13.1::.\ARMCLANG)
  device: GD32A103CB GigaDevice
  pack: GigaDevice.GD32A10x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32A10X
  c include: ..\;..\Soft_Drive;..\..\..\Utilities;..\..\..\Utilities\LCD_Commom;..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_standard_peripheral\Include;..\..\..\..\GD32A10x_Firmware_Library\CMSIS;..\..\..\..\GD32A10x_Firmware_Library\CMSIS\GD\GD32A10x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32a10x_it.c systick.c
  group CMSIS
    ../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group GD32A10x_Peripherals
    ../../../../GD32A10x_Firmware_Library/GD32A10x_standard_peripheral/Source/: gd32a10x_adc.c gd32a10x_bkp.c gd32a10x_can.c gd32a10x_crc.c gd32a10x_ctc.c gd32a10x_dac.c gd32a10x_dbg.c gd32a10x_dma.c gd32a10x_exmc.c gd32a10x_exti.c gd32a10x_fmc.c gd32a10x_fwdgt.c gd32a10x_gpio.c gd32a10x_i2c.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_rtc.c gd32a10x_spi.c gd32a10x_timer.c gd32a10x_usart.c gd32a10x_wwdgt.c
  group GD32A10x_EVAL
    ../../../Utilities/: gd32a103v_eval.c gd32a10x_lcd_eval.c
    ../../../Utilities/LCD_Commom/: lcd_font.c
  group Soft_Drive
    ../Soft_Drive/: rtc.c
  group Startup
    ../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/ARM/: startup_gd32a10x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
