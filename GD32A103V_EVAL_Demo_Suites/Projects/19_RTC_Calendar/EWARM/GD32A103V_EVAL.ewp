# IAR project GD32A103V_EVAL.ewp, settings and files
configuration GD32A10X (ARM, debug)
  General.OGChipSelectEditMenu: GD32A103xB GD GD32A103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GD32A10X
  ICCARM.CCIncludePath2: ..\..\..\..\GD32A10x_Firmware_Library\CMSIS; ..; ..\..\..\..\GD32A10x_Firmware_Library\GD32A10x_standard_peripheral\Include; ..\..\..\..\GD32A10x_Firmware_Library\CMSIS\GD\GD32A10x\Include; ..\..\..\Utilities\LCD_Commom; ..\..\..\Utilities; ..\Soft_Drive
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GD32A103V_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32a10x_it.c main.c systick.c
  group CMSIS
    ../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group Doc
    ../: readme.txt
  group GD32A10x_EVAL
    ../../../Utilities/: gd32a103v_eval.c gd32a10x_lcd_eval.c
    ../../../Utilities/LCD_Commom/: lcd_font.c
  group GD32A10x_Peripherals
    ../../../../GD32A10x_Firmware_Library/GD32A10x_standard_peripheral/Source/: gd32a10x_adc.c gd32a10x_bkp.c gd32a10x_can.c gd32a10x_crc.c gd32a10x_ctc.c gd32a10x_dac.c gd32a10x_dbg.c gd32a10x_dma.c gd32a10x_exmc.c gd32a10x_exti.c gd32a10x_fmc.c gd32a10x_fwdgt.c gd32a10x_gpio.c gd32a10x_i2c.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_rtc.c gd32a10x_spi.c gd32a10x_timer.c gd32a10x_usart.c gd32a10x_wwdgt.c
  group Soft_Drive
    ../Soft_Drive/: rtc.c
  group Startup
    ../../../../GD32A10x_Firmware_Library/CMSIS/GD/GD32A10x/Source/IAR/: startup_gd32a10x.s
